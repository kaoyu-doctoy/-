# Keil uVision project freertos_hello.uvprojx, settings and files
target freertos_hello debug (ARM-ADS)
  device: MIMXRT1064DVL6A NXP
  pack: NXP.MIMXRT1064_DFP.26.03.00
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: freertos_hello.out
  AfterMake: fromelf.exe --output "$Lfreertos_hello.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: DEBUG, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MIMXRT1064DVL6A, MIMXRT1064_SERIES, SDK_OS_FREE_RTOS
  c misc: -include source/mcux_config.h -include source/mcuxsdk_version.h -fno-common -fdata-sections -fno-builtin -mthumb
  c include: board;source;CMSIS;CMSIS/m-profile;component/uart;device;device/periph;drivers;freertos/freertos-kernel/include;freertos/freertos-kernel/portable/GCC/ARM_CM4F;freertos/freertos-kernel/template;freertos/freertos-kernel/template/ARM_CM4F_4_priority_bits;utilities;utilities/debug_console_lite;utilities/str;xip
  asm define: MCUXPRESSO_SDK, CPU_MIMXRT1064DVL6A, MIMXRT1064_SERIES
  asm misc: -include mcux_config.h
  asm include: source;CMSIS;CMSIS/m-profile;component/uart;device;device/periph;drivers;freertos/freertos-kernel/include;freertos/freertos-kernel/portable/GCC/ARM_CM4F;freertos/freertos-kernel/template;freertos/freertos-kernel/template/ARM_CM4F_4_priority_bits;utilities;utilities/debug_console_lite;utilities/str;xip
  library: MicroLIB
  memory RVCT4: ROM 0x70000000 size 0x400000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1064/mdk/MIMXRT1064xxxxx_ram.scf
  link misc: --remove --entry=Reset_Handler --info=sizes,totals,unused,veneers
--remove
  group board
    board/: app.h board.c board.h clock_config.c clock_config.h hardware_init.c pin_mux.c pin_mux.h
  group CMSIS
    CMSIS/: cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm7.h
  group CMSIS/m-profile
    CMSIS/m-profile/: armv7m_cachel1.h armv7m_mpu.h cmsis_armclang_m.h
  group component/uart
    component/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
  group device
    device/: fsl_device_registers.h MIMXRT1064.h MIMXRT1064_COMMON.h MIMXRT1064_features.h system_MIMXRT1064.c system_MIMXRT1064.h
  group device/periph
    device/periph/: PERI_ADC.h PERI_ADC_ETC.h PERI_AIPSTZ.h PERI_AOI.h PERI_BEE.h PERI_CAN.h PERI_CCM.h PERI_CCM_ANALOG.h PERI_CM7_MCM.h PERI_CMP.h PERI_CSI.h PERI_CSU.h PERI_DCDC.h PERI_DCP.h PERI_DMA.h PERI_DMAMUX.h PERI_ENC.h PERI_ENET.h PERI_EWM.h PERI_FLEXIO.h PERI_FLEXRAM.h PERI_FLEXSPI.h PERI_GPC.h PERI_GPIO.h PERI_GPT.h PERI_I2S.h PERI_IOMUXC.h PERI_IOMUXC_GPR.h PERI_IOMUXC_SNVS.h PERI_IOMUXC_SNVS_GPR.h PERI_KPP.h PERI_LCDIF.h PERI_LPI2C.h PERI_LPSPI.h PERI_LPUART.h PERI_OCOTP.h PERI_PGC.h PERI_PIT.h PERI_PMU.h PERI_PWM.h PERI_PXP.h PERI_ROMC.h PERI_RTWDOG.h PERI_SEMC.h PERI_SNVS.h PERI_SPDIF.h PERI_SRC.h PERI_TEMPMON.h PERI_TMR.h PERI_TRNG.h PERI_TSC.h PERI_USB.h PERI_USB_ANALOG.h PERI_USBNC.h PERI_USBPHY.h PERI_USDHC.h PERI_WDOG.h PERI_XBARA.h PERI_XBARB.h PERI_XTALOSC24M.h
  group drivers
    drivers/: fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_dcdc.c fsl_dcdc.h fsl_gpc.c fsl_gpc.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_lpuart.c fsl_lpuart.h fsl_pmu.c fsl_pmu.h fsl_src.c fsl_src.h
    ./drivers/: fsl_pwm.c fsl_pwm.h fsl_qtmr.c fsl_qtmr.h
  group freertos/freertos-kernel
    freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/include
    freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h freertos_tasks_c_additions.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group freertos/freertos-kernel/portable/GCC/ARM_CM4F
    freertos/freertos-kernel/portable/GCC/ARM_CM4F/: port.c portmacro.h
  group freertos/freertos-kernel/portable/MemMang
    freertos/freertos-kernel/portable/MemMang/: heap_4.c
  group freertos/freertos-kernel/portable
    freertos/freertos-kernel/portable/: readme.txt
  group freertos/freertos-kernel/template
    freertos/freertos-kernel/template/: FreeRTOSConfig.h
  group source
    source/: freertos_hello.c FreeRTOSConfig_Gen.h mcux_config.h mcuxsdk_version.h
    ./source/app/: app_config.h app_tasks.c app_tasks.h
    ./source/bsp/: bsp_encoder.c bsp_encoder.h bsp_motor.c bsp_motor.h bsp_soft_i2c.c bsp_soft_i2c.h bsp_uart.c bsp_uart.h
    ./source/chassis/: chassis.c chassis.h
    ./source/control/: pid.c pid.h
    ./source/path/: path_planner.c path_planner.h planner.c planner.h
    ./source/protocol/: protocol.c protocol.h
    ./source/sensor/: imu.c imu.h vision.c vision.h
  group startup/arm
    startup/arm/: startup_MIMXRT1064.S
  group utilities/debug_console_lite
    utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h
  group utilities
    utilities/: fsl_assert.c fsl_assert.h fsl_memcpy.S
  group utilities/str
    utilities/str/: fsl_str.c fsl_str.h
  group xip
    xip/: dcd.c dcd.h evkmimxrt1064_flexspi_nor_config.c evkmimxrt1064_flexspi_nor_config.h fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
target freertos_hello sdram_debug (ARM-ADS)
  device: MIMXRT1064DVL6A NXP
  pack: NXP.MIMXRT1064_DFP.26.03.00
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: freertos_hello.out
  AfterMake: as above
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: DEBUG, USE_SDRAM=1, SKIP_SYSCLK_INIT=1, DATA_SECTION_IS_CACHEABLE=1, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MIMXRT1064DVL6A, MIMXRT1064_SERIES, SDK_OS_FREE_RTOS
  c misc: as above
  c include: as above
  asm define: MCUXPRESSO_SDK, CPU_MIMXRT1064DVL6A, MIMXRT1064_SERIES
  asm misc: -include mcux_config.h
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x70000000 size 0x400000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1064/mdk/MIMXRT1064xxxxx_sdram.scf
  link misc: as above
target freertos_hello flexspi_nor_debug (6240000::V6.24::ARMCLANG)
  device: MIMXRT1064DVL6A NXP
  pack: NXP.MIMXRT1064_DFP.26.03.00
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: freertos_hello.out
  AfterMake: as above
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: DEBUG, XIP_BOOT_HEADER_ENABLE=1, XIP_EXTERNAL_FLASH=1, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MIMXRT1064DVL6A, MIMXRT1064_SERIES, SDK_OS_FREE_RTOS
  c misc: as above
  c include: as above
  asm define: MCUXPRESSO_SDK, CPU_MIMXRT1064DVL6A, MIMXRT1064_SERIES
  asm misc: -include mcux_config.h
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x70000000 size 0x400000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1064/mdk/MIMXRT1064xxxxx_flexspi_nor.scf
  link misc: --remove --predefine=\"-DXIP_BOOT_HEADER_ENABLE=1\" --entry=Reset_Handler --info=sizes,totals,unused,veneers
--remove
target freertos_hello release (ARM-ADS)
  device: MIMXRT1064DVL6A NXP
  pack: NXP.MIMXRT1064_DFP.26.03.00
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: freertos_hello.out
  AfterMake: as above
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: NDEBUG, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MIMXRT1064DVL6A, MIMXRT1064_SERIES, SDK_OS_FREE_RTOS
  c misc: as above
  c include: as above
  asm define: MCUXPRESSO_SDK, CPU_MIMXRT1064DVL6A, MIMXRT1064_SERIES
  asm misc: -include mcux_config.h
  asm include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1064/mdk/MIMXRT1064xxxxx_ram.scf
  link misc: as above
target freertos_hello sdram_release (ARM-ADS)
  device: MIMXRT1064DVL6A NXP
  pack: NXP.MIMXRT1064_DFP.26.03.00
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: freertos_hello.out
  AfterMake: as above
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: NDEBUG, USE_SDRAM=1, SKIP_SYSCLK_INIT=1, DATA_SECTION_IS_CACHEABLE=1, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MIMXRT1064DVL6A, MIMXRT1064_SERIES, SDK_OS_FREE_RTOS
  c misc: as above
  c include: as above
  asm define: MCUXPRESSO_SDK, CPU_MIMXRT1064DVL6A, MIMXRT1064_SERIES
  asm misc: -include mcux_config.h
  asm include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1064/mdk/MIMXRT1064xxxxx_sdram.scf
  link misc: as above
target freertos_hello flexspi_nor_release (ARM-ADS)
  device: MIMXRT1064DVL6A NXP
  pack: NXP.MIMXRT1064_DFP.26.03.00
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: freertos_hello.out
  AfterMake: as above
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: NDEBUG, XIP_BOOT_HEADER_ENABLE=1, XIP_EXTERNAL_FLASH=1, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MIMXRT1064DVL6A, MIMXRT1064_SERIES, SDK_OS_FREE_RTOS
  c misc: as above
  c include: as above
  asm define: MCUXPRESSO_SDK, CPU_MIMXRT1064DVL6A, MIMXRT1064_SERIES
  asm misc: -include mcux_config.h
  asm include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1064/mdk/MIMXRT1064xxxxx_flexspi_nor.scf
  link misc: as above
